Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-04-04T14:46:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Alternate UI 19.2.50.16
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Apr 04 14:46:12 2022* Host: NCL-ManOps17* Database: C:\Users\bateyjo\AppData\Local\Temp\{E4978641-D172-456F-ABB3-FA00C923E133}\ifc* Database version: 5507* Database creation date: Mon Apr 04 14:46:12 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Apr 04 14:46:12 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Apr 04 14:46:12 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: MoreToSeeOneMirrorA430A7, NBS_VilleroyAndBochAG_BthrmMrrs_MoreToSeeOneMirrorA430A7:MoreToSeeOneMirrorA430A7:486282
In: Level 0
Type - ElementType: MoreToSeeOneMirrorA430A7; Classification: Pr_25_71_53_06 (Uniclass2015); Material: NBS_VilleroyAndBoch_Aluminium, NBS_VilleroyAndBoch_Luminous, NBS_VilleroyAndBoch_Mirror
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_BathroomMirrors_MoreToSeeOne_Mirror_A430A7; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/t2zmmccd; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/A430A7; Uniclass2015Title: Bathroom mirrors; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - Colour: 5700 K (daylight white); ContainsRedListMaterials: n/a; ControlMethod: Light switch, not dimmable; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; Dimensions: 500 x 600 x 30 mm; EmbodiedCarbon: n/a; Form: Wall mounted; IngressProtection: 44; IntegralAccessories: n/a; LEDLighting: 1 x LED (6W); Manufacturer: Villeroy and Boch; MaterialsFrame: n/a; MaterialsGlazing: Toughened glass; PowerSupply: Mains-operated; Recyclability: n/a; RecycledContent: n/a; Weight: 3.74 kg
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: BATHMIRROR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: Villeroy and Boch; Material: n/a; ModelNumber: A430A7; ModelReference: MoreToSeeOne_Mirror_A430A7; Name: BathroomMirrors_MoreToSeeOne_Mirror_A430A7_VilleroyAndBochAG; NominalHeight: 600 mm; NominalLength: 0 mm; NominalWidth: 500 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
